# Keil uVision project RkNano.uvproj, settings and files
target RkNano (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano
  AfterMake: fromELF --bin -o RkNano.bin  RkNano.axf
  c flags: wLevel=1
  c include: ..\..\SDK-128x128;..\..\Common\Include;..\..\Common\BootLoader;..\..\Common\System\Os;..\..\Common\System\ModuleOverlay;..\..\Common\System\SysService;..\..\Common\System\FileSeek;..\..\Common\Driver;..\..\Common\Driver\NVIC;..\..\Common\Driver\EMCTL;..\..\Common\Driver\ADC;..\..\Common\Driver\DMA;..\..\Common\Driver\PWM;..\..\Common\Driver\I2C;..\..\Common\Driver\IIS;..\..\Common\Driver\PLL;..\..\Common\Driver\SCU;..\..\Common\Driver\PMU;..\..\Common\Driver\GPIO;..\..\Common\Driver\IOMUX;..\..\Common\Driver\SPI;..\..\Common\Driver\TIMER;..\..\Common\Driver\SYSTICK;..\..\Common\Driver\SDMMC;..\..\Common\Driver\LCD;..\..\Common\Driver\KEY;..\..\Common\Driver\AD_KEY;..\..\Common\Driver\DAC;..\..\Common\Driver\DAC\rockcodec;..\..\Common\Driver\DAC\wm8987;..\..\Common\Driver\RadioDriver\QN8035;..\..\Common\FileSys;..\Resource;..\UI\dialog;..\UI\MainMenu;..\UI\MusicWin;..\UI\RadioWin;..\UI\PicWin;..\UI\RadioWin\RadioSubWin;..\UI\RecordWin;..\UI\TextWin;..\UI\Browser\BroCore;..\UI\Browser\BrowserUI;..\UI\SetMenu;..\UI\USB;..\..\Common\Codec\Audio\AudioControl;..\..\Common\Codec\Audio\Effect;..\..\Common\Codec\Audio\Include;..\..\Common\Codec\Audio\Spectrum;..\..\Common\Codec\Audio\RkEQ;..\..\Common\Codec\Audio\RkEQ\Effect;..\..\Common\Codec\Audio\RecordControl;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wav\WAV_LIB;..\..\Common\Codec\Radio;..\..\Common\Codec\Radio\FMControl;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\VideoControl;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Audio\ID3;..\..\Common\Codec\Audio\ID3\MusicAlbumJpgDec;..\UI\block;..\..\Common\SortFileInfo;..\UI\medialib;..\Scatter;..\..\Common\Driver\UART;..\..\Common\Driver\Nand;..\..\Common\Driver\DAC;..\..\Common\Driver\DAC\wm8987;..\..\Common\Driver\IMDCT36_SYNTH;..\..\Common\Codec\Audio\Aac;..\..\Common\Codec\Audio\ShuffleAll;..\..\Common\Driver\USB;..\..\Common\Driver\MemDev;..\..\Common\Driver\MemDev\Nand;..\..\Common\Driver\MemDev\SD_MMC;..\..\Common\Driver\MemDev\SpiNor;..\..\Common\System\Mdb;..\..\Common\System\Mdb\id3;..\..\Common\System\Mtp;..\UI\CharegeWin;..\..\Common\Driver\RTC;..\..\Common\wireless\include;..\..\Common\wireless\wifi_driver\rkwifi_src\include;..\..\Common\wireless\wifi_driver\rkwifi_src\include\proto;..\..\Common\wireless\sdio;..\..\Common\wireless\sdio\common;..\..\Common\wireless\sdio\malloc;..\..\Common\wireless\wifi_driver\rkwifi_src;..\..\Common\wireless\wifi_driver\Firmware;..\..\Common\LwIp;..\..\Common\NetRadio;..\..\Common\wireless\wifi_driver\wpa_config;..\..\Common\Xml;..\UI\WiFiWin
  library: MicroLIB
  scatter file: ..\Scatter\scatter.sct
  link misc: --keep ModuleInfo --keep eqArray --keep uldiv.o --keep ldiv.o --keep llshl.o --keep llushr.o --keep llsshr.o --keep siabs.o --keep memmovea.o --keep memseta.o --keep strcat.o --keep strncpy.o --keep strxfrm.o --keep strchr.o --keep strlen.o --keep strcmp.o --keep memchr.o --keep memcmp.o --keep strncat.o --keep strcoll.o --keep strcpy.o --keep strncmp.o --keep strrchr.o --keep strspn.o --keep strcspn.o --keep strpbrk.o --keep dadd.o --keep dmul.o --keep ddiv.o --keep dflt.o --keep dfltu.o --keep dfltll.o --keep dfltull.o --keep dfix.o --keep dfixu.o --keep dfixll.o --keep dfixull.o --keep f2d.o --keep cdcmple.o --keep cdrcmple.o --keep fadd.o --keep fmul.o --keep fdiv.o --keep fflt.o --keep ffltu.o --keep ffltll.o --keep ffltull.o --keep ffix.o --keep ffixu.o --keep ffixll.o --keep ffixull.o --keep d2f.o --keep cfcmple.o --keep cfrcmple.o --keep iusefp.o --keep depilogue.o --keep fepilogue.o
  group Boot
    ../../Common/BootLoader/: microlibuse.c Dumy.c Start.s
    ../Scatter/: ScatterLoader.c
  group Driver
    ../../Common/Driver/PLL/: Pll.c
    ../../Common/Driver/SCU/: scu.c
    ../../Common/Driver/PMU/: PMU.C
    ../../Common/Driver/ADC/: Adc.c
    ../../Common/Driver/DMA/: Dma.c
    ../../Common/Driver/I2C/: i2c.c
    ../../Common/Driver/IIS/: I2s.c
    ../../Common/Driver/PWM/: pwm.c
    ../../Common/Driver/GPIO/: gpio.c
    ../../Common/Driver/SPI/: Spi.c
    ../../Common/Driver/SYSTICK/: systick.c
    ../../Common/Driver/TIMER/: timer.c
    ../../Common/Driver/AD_KEY/: AD_Key.c
    ../../Common/Driver/UART/: uart.c
    ../../Common/Driver/DAC/rockcodec/: rockcodec.c
    ../../Common/Driver/LCD/: LCD1.5_ST7637_128x128_1.0.c LCD1.8_ST7735_1.0.c
  group System
    ../../Common/System/Debug/: Debug.c
    ../: main.c
    ../../Common/System/SysService/: Hook.c Delay.c Service.c UsbAdapterProbe.c
    ../../Common/System/Os/: interrupt.c SysTickHandler.c
    ../../Common/System/ModuleOverlay/: protocol.c
  group OsLib
    ../../Common/System/Os/: Msg.c Win.c Thread.c Task.c OsHook.c
    ../../Common/System/ModuleOverlay/: ModuleOverlay.c SysReservedOperation.c
  group FileSys
    ../../Common/FileSys/: Decode.c nFAT.c fat.c FDT.c dir.c file.c FileSeek.c flashfile.c
  group App
    ../UI/dialog/: DialogBox.c MessageBox.c Hold.c PowerOn_Off.c
    ../UI/MainMenu/: MainMenu.c
    ../UI/USB/: FunUSB.c FunUSBInterface.c
    ../UI/WiFiWin/: WiFiAPWin.c WiFiKeyboardWin.c WiFiPlayWin.c WiFiMusicBrowWin.c
  group USB
    ../../Common/Driver/USB/: USBIsr.c BulkOnly.c Chap_9.c USBCtrl.c USBDrv.c
  group AudioControl
    ../../Common/Codec/Audio/Common/: audio_file_access.c
  group MemDev
    ../../Common/Driver/MemDev/: MemDev.c
    ../../Common/Driver/MemDev/Nand/: ftl.c NandFlash.c NandVendor.c
    ../../Common/Driver/MemDev/SD_MMC/: SDM.c eMMC.c MMC.c SD.c SDAdapt.c SDCtrl.c
    ../../Common/Driver/MemDev/SpiNor/: SpiNor.c
  group WirelessSdio
    ../../Common/wireless/sdio/common/: sdio.c sdio_cis.c sdio_ctrl.c sdio_io.c sdio_irq.c sdio_ops.c sdiom.c wificommon.c wificontrol.c
    ../../Common/wireless/sdio/malloc/: sys_malloc.c
  group Wifi_RK903
    ../../Common/wireless/wifi_driver/rkwifi_src/: aiutils.c bcmsdh.c bcmsdh_linux.c bcmsdh_sdmmc.c bcmsdh_sdmmc_linux.c bcmutils.c dhd_cdc2.c dhd_common.c dhd_linux.c dhd_sdio.c dhd_txrx_process.c hndpmu.c siutils.c wl_iw.c
  group LwIp
    ../../Common/LwIp/: autoip.c dhcp.c dns.c icmp.c inet.c inet_chksum.c ip.c netif.c pbuf.c tcp.c tcp_in.c tcp_out.c udp.c
  group NetRadio
    ../../Common/NetRadio/: eth.c http.c Netfile.c NetFindFile.c tools.c
  group wpa_supplicant
    ../../Common/wireless/wpa_supplicant/: aes_wrap.c driver_wext.c eloop.c os_internal.c wpa.c wpa_aes.c wpa_md5.c wpa_rc4.c wpa_sha1.c wpa_supplicant.c
  group xml
    ../../Common/Xml/: XmlAnalyze.c
