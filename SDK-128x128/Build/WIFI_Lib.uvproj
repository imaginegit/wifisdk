# Keil uVision project WIFI_Lib.uvproj, settings and files
target RkNano (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RkNano (library)
  c flags: Optim=3 wLevel=1
  c include: ..\..\SDK-128x128;..\..\Common\Include;..\..\Common\BootLoader;..\..\Common\System\Os;..\..\Common\System\ModuleOverlay;..\..\Common\System\SysService;..\..\Common\System\FileSeek;..\..\Common\Driver;..\..\Common\Driver\NVIC;..\..\Common\Driver\EMCTL;..\..\Common\Driver\ADC;..\..\Common\Driver\DMA;..\..\Common\Driver\PWM;..\..\Common\Driver\I2C;..\..\Common\Driver\IIS;..\..\Common\Driver\PLL;..\..\Common\Driver\SCU;..\..\Common\Driver\PMU;..\..\Common\Driver\GPIO;..\..\Common\Driver\IOMUX;..\..\Common\Driver\SPI;..\..\Common\Driver\TIMER;..\..\Common\Driver\SYSTICK;..\..\Common\Driver\SDMMC;..\..\Common\Driver\LCD;..\..\Common\Driver\KEY;..\..\Common\Driver\AD_KEY;..\..\Common\Driver\DAC;..\..\Common\Driver\DAC\rockcodec;..\..\Common\Driver\DAC\wm8987;..\..\Common\Driver\RadioDriver\FM5767;..\..\Common\FileSys;..\Resource;..\..\Common\Display;..\UI\dialog;..\UI\MainMenu;..\UI\MusicWin;..\UI\RadioWin;..\UI\PicWin;..\UI\RadioWin\RadioSubWin;..\UI\RecordWin;..\UI\TextWin;..\UI\Browser\BroCore;..\UI\Browser\BrowserUI;..\UI\SetMenu;..\UI\USB;..\..\Common\Codec\Audio\AudioControl;..\..\Common\Codec\Audio\Effect;..\..\Common\Codec\Audio\Include;..\..\Common\Codec\Audio\Mp3;..\..\Common\Codec\Audio\Spectrum;..\..\Common\Codec\Audio\RkEQ;..\..\Common\Codec\Audio\RkEQ\Effect;..\..\Common\Codec\Audio\RecordControl;..\..\Common\Codec\Audio\Wav;..\..\Common\Codec\Audio\Wav\WAV_LIB;..\..\Common\Codec\Radio;..\..\Common\Codec\Radio\FMControl;..\..\Common\Codec\Image\Imagecontrol;..\..\Common\Codec\Video\mp2;..\..\Common\Codec\Video\VideoControl;..\..\Common\Codec\Video\Avi\AviFile;..\UI\VideoWin;..\..\Common\Codec\Video\Avi;..\..\Common\Codec\Audio\ID3;..\..\Common\Codec\Audio\ID3\MusicAlbumJpgDec;..\UI\block;..\..\Common\SortFileInfo;..\UI\medialib;..\Scatter;..\..\Common\Driver\UART;..\..\Common\Driver\Nand;..\..\Common\Driver\DAC;..\..\Common\Driver\DAC\wm8987;..\..\Common\Driver\IMDCT36_SYNTH;..\..\Common\Codec\Audio\Aac;..\..\Common\Codec\Audio\ShuffleAll;..\..\Common\Driver\USB;..\..\Common\Driver\MemDev;..\..\Common\Driver\MemDev\Nand;..\..\Common\Driver\MemDev\SD_MMC;..\..\Common\Driver\MemDev\SpiNor;..\..\Common\Driver\RTC;..\UI\CharegeWin;..\..\Common\LwIp;..\..\Common\NetRadio;..\..\Common\wireless\include;..\UI\WiFiWin;..\..\Common\wireless\sdio\common;..\..\Common\wireless\sdio\malloc;..\..\Common\wireless\wifi_driver\Firmware;..\..\Common\wireless\wifi_driver\rkwifi_src;..\..\Common\wireless\wifi_driver\rkwifi_src\include;..\..\Common\wireless\wifi_driver\rkwifi_src\include\proto;..\..\Common\wireless\wpa_supplicant;..\UI\SysTest;..\UI\Register;..\..\Common\Database
  library: MicroLIB
  scatter file: ..\Scatter\scatter.sct
  link misc: --keep ModuleInfo --keep eqArray --keep uldiv.o --keep ldiv.o --keep llshl.o --keep llushr.o --keep llsshr.o --keep siabs.o --keep memmovea.o --keep memseta.o --keep strcat.o --keep strncpy.o --keep strxfrm.o --keep strchr.o --keep strlen.o --keep strcmp.o --keep memchr.o --keep memcmp.o --keep strncat.o --keep strcoll.o --keep strcpy.o --keep strncmp.o --keep strrchr.o --keep strspn.o --keep strcspn.o --keep strpbrk.o --keep dadd.o --keep dmul.o --keep ddiv.o --keep dflt.o --keep dfltu.o --keep dfltll.o --keep dfltull.o --keep dfix.o --keep dfixu.o --keep dfixll.o --keep dfixull.o --keep f2d.o --keep cdcmple.o --keep cdrcmple.o --keep fadd.o --keep fmul.o --keep fdiv.o --keep fflt.o --keep ffltu.o --keep ffltll.o --keep ffltull.o --keep ffix.o --keep ffixu.o --keep ffixll.o --keep ffixull.o --keep d2f.o --keep cfcmple.o --keep cfrcmple.o --keep iusefp.o --keep depilogue.o --keep fepilogue.o
  group WirelessSdio
    ../../Common/wireless/sdio/common/: sdio.c sdio_cis.c sdio_ctrl.c sdio_io.c sdio_irq.c sdio_ops.c sdiom.c wificommon.c
    ../../Common/wireless/sdio/malloc/: sys_malloc.c
  group WirelessDriver
    ../../Common/wireless/wifi_driver/rkwifi_src/: aiutils.c bcmsdh.c bcmsdh_linux.c bcmsdh_sdmmc.c bcmsdh_sdmmc_linux.c bcmutils.c dhd_cdc2.c dhd_common.c dhd_linux.c dhd_sdio.c dhd_txrx_process.c hndpmu.c siutils.c wl_iw.c
  group wirelessWpa
    ../../Common/wireless/wpa_supplicant/: aes_wrap.c driver_wext.c eloop.c os_internal.c wpa.c wpa_aes.c wpa_md5.c wpa_rc4.c wpa_sha1.c wpa_supplicant.c
  group LwIp
    ../../Common/LwIp/: autoip.c dhcp.c dns.c icmp.c inet.c inet_chksum.c ip.c netif.c pbuf.c tcp.c tcp_in.c tcp_out.c udp.c
